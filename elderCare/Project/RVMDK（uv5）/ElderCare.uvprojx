# Keil uVision project ElderCare.uvprojx, settings and files
target elderCare (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ElderCare +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\sim900;..\..\User\onenet\inc;..\..\User\EDP;..\..\User\hwtimer;..\..\User\mlx90614;..\..\User\warning;..\..\FreeROTS\include;..\..\FreeROTS\portable\RVDS\ARM_CM3;..\..\FreeROTS\portable\MemMang;..\..\MyTask
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/dht11/: bsp_dht11.c
    ../../User/usart/: bsp_usart.c
    ../../User/sim900/: sim900.c
    ../../User/hwtimer/: hwtimer.c
    ../../User/mlx90614/: mlx90614.c
    ../../User/warning/: warning.c
  group DOC
    ../../Doc/: readme.txt
  group NetWork
    ../../User/onenet/src/: onenet.c
  group net_protocol
    ../../User/EDP/: EdpKit.c
  group FreeRTOS
    ../../FreeROTS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../../FreeROTS/portable/RVDS/ARM_CM3/: port.c
    ../../FreeROTS/portable/MemMang/: heap_4.c
  group MyTask
    ../../MyTask/: dht11_task.c mlx90614_task.c sim900_task.c
